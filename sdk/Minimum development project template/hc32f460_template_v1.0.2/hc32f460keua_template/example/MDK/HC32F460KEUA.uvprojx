# Keil uVision project HC32F460KEUA.uvprojx, settings and files
target HC32F460KEUA_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460KEUA HDSC
  pack: HDSC.HC32F46x.1.0.0
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HC32F460KEUA
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __DEBUG,HC32F46x
  c misc: --diag_suppress=186
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group common
    ./: startup_hc32f460keua.s
    ../../common/: system_hc32f460keua.c
  group source
    ../source/: main.c
software components: CMSIS:CORE 5.0.1
