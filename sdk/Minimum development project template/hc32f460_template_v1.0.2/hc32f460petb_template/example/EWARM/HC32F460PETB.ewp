# IAR project HC32F460PETB.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f460petb.srec
  ILINK.IlinkOutputFile: hc32f460petb.out
  ILINK.IlinkIcfFile: config\HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  group common
    ../../common/: system_hc32f460petb.c
    ./: startup_hc32f460petb.s
  group source
    ../source/: main.c
